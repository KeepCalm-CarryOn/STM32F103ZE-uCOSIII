# Keil uVision project μCOSIII.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: μCOSIII +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Hardware\delay;..\Lib\Cmsis;..\Lib\Fwlib\inc;..\ucosIII\CPU;..\ucosIII\CPU\Ports\ARM-Cortex-M3\Generic\RealView;..\ucosIII\CPU\ARM-Cortex-M3\RealView;..\ucosIII\LIB;..\ucosIII\LIB\Ports\ARM-Cortex-M3\RealView;..\ucosIII\SOURCE;..\ucosIII\CONFIG;..\ucosIII\BSP;..\ucosIII\BSP\OS\uCOS-III
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: README.txt stm32f10x_it.c system_stm32f10x.c app.c
    ../Lib/Startup/: startup_stm32f10x_hd.s
  group HEADWARE
    ../Hardware/delay/: delay.c
  group CMSIS
    ../Lib/Cmsis/: core_cm3.c
  group FWLIB
    ../Lib/Fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group μCOSIII-CPU
    ../ucosIII/CPU/: cpu_core.c
    ../ucosIII/CPU/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
    ../ucosIII/CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group μCOSIII-SOURCE
    ../ucosIII/SOURCE/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group μCOSIII-LIB
    ../ucosIII/LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../ucosIII/LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group μCOSIII-BSP
    ../ucosIII/BSP/: bsp.c
